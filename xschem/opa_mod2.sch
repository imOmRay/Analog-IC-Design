** sch_path: xschem/opa_mod2.sch
**.subckt opa_mod2
E1 net3 net4 net1 GND 1
E2 net2 GND net5 net6 1000
R1 net2 net1 200 m=1
C1 net1 GND 1u m=1
**.ends
.GLOBAL GND
.end
